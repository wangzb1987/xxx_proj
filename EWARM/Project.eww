<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\xxx_v1.ewp</path>
  </project>
  <batchBuild />
</workspace>
